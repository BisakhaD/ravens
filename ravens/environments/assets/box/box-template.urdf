Commit message: 6-dof shelf placing

File: ravens/environments/assets/box/box-template.urdf (robot description, URDF)
Before this commit: robot box.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=0.05666667, 0.19, 0.19; visual box size=0.05666667, 0.19, 0.19
